## package/batocera/boot/uboot-youyeetoo-r1/Config.in
```kconfig
config BR2_PACKAGE_UBOOT_YOUYEETOO_R1
    bool "uboot-youyeetoo-r1"
    help
      U-Boot files for Youyeetoo R1
```
